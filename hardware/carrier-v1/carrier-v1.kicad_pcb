# Repository nasacj/rtlsdr-iphone-bridge

File README.md:

# rtlsdr-iphone-bridge

**English** | [中文](README.zh-CN.md)

Turn an RTL-SDR into an `rtl_tcp` server on Wi-Fi, using a development board that costs a few dollars and
**needs no soldering**. Any `rtl_tcp` SDR app on an iPhone joins the board's Wi-Fi, enters one address, and receives.

## Why

An iPhone that is not jailbroken cannot drive an RTL-SDR. The RTL-SDR is a USB bulk-transfer device, and iOS gives
ordinary apps neither libusb nor IOKit; DriverKit exists only on M-series iPads. This is a limit of the iOS
architecture, not of App Store review. So every SDR app on the App Store is a **network client**: the RTL-SDR
plugs into another machine running `rtl_tcp`, and the phone connects to it over the network.

The trouble is the other machine. A laptop is too big. A Raspberry Pi needs an SD card and an operating system,
takes half a minute to boot and draws several watts. To take a phone to an airport for ADS-B or up a hill for APRS
you want something that **fits in a pocket, runs from a power bank, and works a few seconds after power-on**.

That is what this is:

- **The board**: Ai-Thinker's Ai-M61-32S-Kit (Bouffalo BL618), with a high-speed USB host port, Wi-Fi and
  4 MB of PSRAM, for a few dollars.
- **The wiring**: four jumper wires to a USB-A socket, and the RTL-SDR plugs into that. No soldering iron.
- **Using it**: at power-on the board starts its own Wi-Fi hotspot. Join it from the phone and enter
  `rtlsdr.local` (or `192.168.7.1`) in the app. Or let the board join the phone's Personal Hotspot instead,
  so the phone keeps its internet connection.
- **The protocols**: port 1234 is unmodified `rtl_tcp`, so existing apps work without a single change.
  Port 1235 also offers `rtl_udp`, for clients that want to know exactly which samples were lost.
- **The licence stays off the phone**: the firmware contains librtlsdr and is therefore GPL. Between an app and the
  board there is only a network protocol, so the app contains none of this code and App Store distribution is
  unaffected.

Computers work too: SDR++, GQRX and anything else that speaks `rtl_tcp` take the same address.

## How fast

Wi-Fi is the narrowest part of the path. The BL618 has one antenna on 2.4 GHz with 20 MHz channels, and sustains a
little over 30 Mbit/s in practice. RTL-SDR I/Q is two bytes a sample, so 2.4 MSPS is 38.4 Mbit/s, right at the
edge. Measured with the board running its own hotspot and the receiver connected directly:

| Use | Sample rate | Data rate | Measured |
|---|---|---|---|
| FM broadcast, airband, amateur bands | 1.024 MSPS | 16.4 Mbit/s | nothing lost |
| Wider spectrum | 2.0 MSPS | 32 Mbit/s | nothing lost (with the board placed well) |
| Widest | 2.4 MSPS | 38.4 Mbit/s | 80–95% delivered; the rest is dropped on the board and the client is told where |
| ADS-B (`rtl_udp`, magnitudes only) | 2.0–2.4 MSPS | 16–19 Mbit/s | nothing lost |

Things that halve the throughput: **Bluetooth on the receiving device** (it shares 2.4 GHz airtime with Wi-Fi;
measured 29 down to 15 Mbit/s), **jumper wires or a hand close to the board's antenna**, and distance.
For I/Q, stay at 2.0 MSPS or below.

Why UDP does not fill the link either: UDP itself waits for no acknowledgement, but Wi-Fi does. Every unicast frame
must be acknowledged by the receiver or it is retransmitted; that is 802.11, and no protocol above it avoids it.
Broadcast frames are not acknowledged, but they go at the 1–6 Mbit/s basic rate, which is slower still.

## Known issue

While Wi-Fi runs, something outside the CPU (most likely the Wi-Fi hardware) zeroes one fixed
4-byte word of PSRAM, at `0xa8201300`, every few minutes. The firmware keeps no samples there: a
1 MB guard covers that address, and the boot log says `ring guard covers 0xa8201300`. Reported
upstream as [bouffalo_sdk#272](https://github.com/bouffalolab/bouffalo_sdk/issues/272); the
details are in [firmware/bl618_rtl_udp/README.md](firmware/bl618_rtl_udp/README.md) (in Chinese).

## What you need

| Item | Notes | Approx. |
|---|---|---|
| **Ai-M61-32S-Kit** | Ai-Thinker's own development board, chip **BL618**, with 4 MB PSRAM. Listings that say "BL616" are the Ai-M62, which **has no PSRAM and will not work** | US$5–8 |
| **USB-A female to 4-pin jumper cable** | A USB-A socket on one end and four separate 2.54 mm female jumper connectors on the other (sold for motherboard headers). **Not the 9-pin kind**, which is for a two-row header. Shorter is better | US$1–2 |
| **RTL-SDR** | RTL-SDR Blog V3, V4, or any other RTL2832U stick | — |
| **Type-C cable and power** | To a computer for flashing; to a power bank or charger otherwise, **at least 5 V 1 A** (about 500 mA for the board, 250–300 mA for the RTL-SDR) | — |
| Antenna | The one that came with the RTL-SDR is fine to start | — |

The board's Type-C port already has a USB-serial chip (CH340C) behind it, used for flashing and for the log, so
**no separate serial adapter is needed**.

Building needs an **x86_64 Linux** machine (physical, virtual or cloud; CentOS Stream 9 is the one verified), for the
reason under [Build](#build). Flashing works from Linux or from a Mac.

## Wiring

Lay the board **front side up, antenna at the top, Type-C at the bottom**, and connect four wires:

| USB-A socket | Board pin (silkscreen) | Where on the board | Usual wire colour |
|---|---|---|---|
| VBUS | `5V` | left row, 2nd from the bottom | red |
| GND | `GND` | left row, bottom pin | black |
| D− | `USB_DM` | right row, 6th from the bottom (the pin above it is `IO23`) | white |
| D+ | `USB_DP` | right row, 5th from the bottom (the pin below it is `IO9/NC`) | green |

Before powering up:

1. **Unplug the Type-C cable** while wiring, and plug it back in only when all four wires are on.
2. **Do not swap 5V and GND**: that can destroy the RTL-SDR. Trust your own cable over any colour code; if in doubt,
   check the socket with a multimeter. The two outer contacts are VBUS and GND, the two inner ones are data.
3. Swapping `USB_DM` and `USB_DP` damages nothing; the RTL-SDR is simply not recognised. Swap them back.
4. The data pair carries 480 Mbit/s. Keep the two wires **together and as short as possible**.
5. The same names are printed on the back of the board, but seen from the back the two rows swap sides.
   Go by the front.

The RTL-SDR is powered from the board's `5V` pin through a diode, so it gets a few tenths of a volt less than 5 V.
RTL-SDRs normally accept that. If it is not recognised, or keeps disconnecting, suspect power first: use a stronger
charger, or measure the voltage on the `5V` pin.

## A board of its own

The kit and four wires are the quick way in. The same circuit also exists as one board, with a USB-A socket
for the RTL-SDR, so nothing is wired by hand:

*One of the first two boards, running: power on the USB-C port, the RTL-SDR's cable in the USB-A socket,
the yellow lamp steady, which means the RTL-SDR is recognised and ready.*

*The same board as the KiCad files draw it: 62.6 × 34.6 mm, four layers.*

- A slide switch chooses where the RTL-SDR goes: to the BL618, for Wi-Fi, or straight to a computer through
  the USB-C port, where it shows up as an ordinary RTL2832U.
- The USB-C port also carries the serial port for the log and for flashing, in either position.
- The first two boards have been built and tested: both modes work, and an iPhone receives 2.4 MSPS over Wi-Fi
  with no samples lost on the USB side.

The design is generated from scripts and is all in [hardware/carrier-v1/](hardware/carrier-v1/): netlist,
KiCad files, parts list with LCSC numbers. [BRINGUP.md](hardware/carrier-v1/BRINGUP.md) records what was
measured on the first boards and the one part that had to change. Those two documents are in Chinese.

## Build

The firmware builds only on **x86_64 Linux**. The Wi-Fi library in Bouffalo's SDK is shipped as GCC 10.2 LTO
bytecode, which links only with Bouffalo's XuanTie GCC **v2.6.1** (the newer v2.10.2 refuses it), and v2.6.1 exists
only for x86_64 Linux. WSL2 on Windows may work; it has not been tried.

```bash
git clone https://github.com/nasacj/rtlsdr-iphone-bridge.git
cd rtlsdr-iphone-bridge

# Bouffalo's SDK (about 2 GB) and XuanTie GCC v2.6.1, pinned, into firmware/deps/
firmware/tools/fetch-deps.sh bl618

export PATH=$PWD/firmware/deps/xuantie-gcc-2.6.1/bin:$PATH
cd firmware/bl618_rtl_udp
make
```

The result is `firmware/bl618_rtl_udp/build/build_out/bl618_rtl_udp_bl616.bin`, about 1.1 MB.
The system needs `git`, `make`, `cmake`, `curl` and `xz`.

To change the Wi-Fi settings before building, see [Wi-Fi settings](#wi-fi-settings). The defaults work as they are.

## Flash

**1. Put the board in download mode.** The kit has no automatic download circuit, so this is by hand every time:

> hold **IO2** → press and release **EN** → release IO2

The two buttons sit either side of the Type-C port: EN on the left, IO2 on the right (see the wiring diagram).

**2. Write the firmware.** The serial port is usually `/dev/ttyUSB0` on Linux and `/dev/tty.usbserial-XXXX` or
`/dev/tty.wchusbserial-XXXX` on a Mac. Run `ls /dev/tty*` before and after plugging the board in; the new one is it.

On the Linux machine that built it:

```bash
cd firmware/bl618_rtl_udp
make flash COMX=/dev/ttyUSB0 BAUDRATE=500000
```

**Give the baud rate**: the SDK defaults to 2 Mbaud, and the board's CH340C flashes at 500 kbaud at most.

With the board plugged into a Mac (building still happens on Linux):

```bash
firmware/tools/fetch-deps.sh bl618                 # on a Mac this fetches only the flasher, about 76 MB
echo my-linux-box > firmware/tools/build-host      # ssh name of the build machine; not committed
firmware/tools/flash-bl618.sh /dev/tty.usbserial-XXXX
```

`flash-bl618.sh` copies the build from the build machine and flashes it. `BL618_HOST=...` works instead of the
`build-host` file.

**3. Press EN** and the new firmware runs.

**A bare module on your own board, with no boot button that works.** On a plain Ai-M61-32S module the IO2 pad on
the edge is not connected inside; IO2 is a round test point on the module's back, and only modules marked `A` or
`ALL` bring it out to the edge. The kit carries such a module, so its button works. For a module that is already
soldered down, boot2 takes a handshake over the serial port instead:

```bash
firmware/tools/flash-bl618.sh --isp /dev/cu.usbmodemXXXX     # press reset once when it asks
```

Press reset **once**: a second press takes the chip back out of download mode. It needs a serial chip that does
2 Mbaud, and a boot2 already in the flash, which the factory AT firmware and this firmware both have.

If flashing stalls at the write step and times out after 30 seconds, set `decompress_write = false` in the flasher's
`chips/bl616/eflash_loader/eflash_loader_cfg.ini`, unplug and replug the board, and try again. The flasher compresses
the image by default and the board must decompress it and acknowledge within 30 seconds, which a larger image may
not manage at 500 kbaud.

Reflashing does **not** change the Wi-Fi password: it lives in a separate part of the flash that flashing leaves alone.

## First boot: the Wi-Fi name and password

By default the board **starts its own hotspot**, named `SDR-Bridge-` plus four hex digits of the chip ID, for example
`SDR-Bridge-3F2A`. **Every board has its own password**: twelve characters drawn from the chip's hardware random
number generator on first boot, stored in flash, and the same on every boot after that.

The password is printed only on the serial log. Connect the board's Type-C to a computer, open the serial port at
**2,000,000 baud**, and press EN:

```bash
tio -b 2000000 /dev/ttyUSB0                  # Linux (or: picocom -b 2000000 /dev/ttyUSB0)
tio -b 2000000 /dev/tty.usbserial-XXXX       # Mac: brew install tio
```

The boot log has a line like this:

```
[wifi] network "SDR-Bridge-3F2A" up, password xxxxxxxxxxxx
```

Note the name and the password, and you will not need a computer again.

Why not a fixed password: `rtl_tcp` has no authentication at all. Anyone on the Wi-Fi can retune the receiver and
read every sample, so the Wi-Fi password is the only lock there is. A fixed password published in an open-source
repository is no lock, and one derived from the chip ID is no better, because the chip ID is in the MAC address the
board broadcasts.

## Wi-Fi settings

The Wi-Fi settings live in `firmware/bl618_rtl_udp/wifi_secrets.h`. It is not committed; start from the template:

```bash
cd firmware/bl618_rtl_udp
cp wifi_secrets.h.example wifi_secrets.h
```

The settings are compiled in, so **rebuild and reflash** after changing them.

**Choose the hotspot password yourself:**

```c
#define BRIDGE_STA_SSID ""                  // empty: the board keeps starting its own hotspot
#define BRIDGE_STA_KEY  ""
#define BRIDGE_AP_KEY   "my-password-123"   // 8 to 63 characters
```

**Have the board join your phone's Personal Hotspot** (the phone keeps its internet):

```c
#define BRIDGE_STA_SSID "Jane’s iPhone"     // exactly as Settings shows it, curly ’ included
#define BRIDGE_STA_KEY  "hotspot password"
```

- At power-on the board tries that network, and **falls back to its own hotspot after 20 seconds**, so a typo
  cannot lock you out.
- On the phone's hotspot the board's address is assigned by the phone; the `got ip` line in the serial log shows it
  (an iPhone hotspot is usually `172.20.10.x`). Enter `rtlsdr.local` in the app and the address does not matter.
- The BL618 is **2.4 GHz only**. On an iPhone, turn on **Maximize Compatibility** for the Personal Hotspot; on a
  home router, use its 2.4 GHz network name.

**Two boards on one phone**, one receiver each. Each board needs its own name, and both join the phone's
hotspot. The same settings can be given on the command line instead of edited into the file — once per board,
just before building for it:

```sh
firmware/tools/configure-bl618.sh --join "Jane’s iPhone" --name rtlsdr-atc    # asks for the password
firmware/tools/build-all.sh && firmware/tools/flash-bl618.sh /dev/cu.usbserial-XXXX
firmware/tools/configure-bl618.sh --join "Jane’s iPhone" --name rtlsdr-adsb
firmware/tools/build-all.sh && firmware/tools/flash-bl618.sh /dev/cu.usbserial-YYYY
```

- The app then reaches them as `rtlsdr-atc.local` and `rtlsdr-adsb.local`. A name is lower-case letters, digits
  and hyphens; a dot is not allowed inside one.
- `--own --name rtlsdr` is a board that opens its own hotspot; `--show` says what the next build is for (the build
  prints it too); `--clear` goes back to `wifi_secrets.h`.
- The settings are written to `firmware/bl618_rtl_udp/board_settings.h`, which is not committed, and override
  `wifi_secrets.h` for what they set.

**A password that has been given away** (when `BRIDGE_AP_KEY` is not set): type `bridge_ap_newkey` on the serial
console, press EN to restart, and the board draws and prints a new random password.

## Connect an app

1. Join the phone to `SDR-Bridge-XXXX` (or let the board join the phone's hotspot, as above).
   The board's hotspot has no internet; iOS keeps using mobile data for that, so other apps are unaffected.
2. In an `rtl_tcp` SDR app, enter the server **`rtlsdr.local`**, port **`1234`**.
   If `rtlsdr.local` does not resolve, use **`192.168.7.1`** (the board's address on its own hotspot).
3. The first time, iOS asks whether the app may access the local network. Allow it.

One client is served at a time, and a new connection replaces the old one (which is what an app reconnecting does).

## Status lights

Away from a computer, running from a power bank, the lights tell you what the board is doing. There is an RGB light
and two single-colour lights, a yellow one marked **W** and a white one marked **C** on the silkscreen.
All three use the same language:
**slow blink = waiting, steady = ready, breathing = working, fast blink = trouble.**

| Light | Answers | Slow blink | Steady | Breathing | Fast blink |
|---|---|---|---|---|---|
| **Yellow (W)** | Is the RTL-SDR OK? | no RTL-SDR plugged in | RTL-SDR ready | — | plugged in but cannot be opened, or USB delivers nothing |
| **White (C)** | How far have Wi-Fi and the phone got? | Wi-Fi up, waiting for a phone | phone connected, not streaming | streaming | — |
| **RGB** | Is the stream healthy? | — | red: Wi-Fi not up yet | blue: streaming, all well | red/blue: data lost on the USB side; purple/blue: Wi-Fi cannot keep up, data lost |

- White **off** means Wi-Fi is not up yet.
- The RGB light is off when nothing is streaming and nothing is wrong. When a stream ends by itself it shows
  **red for 3 seconds**; the reason is on the serial log's `session ended:` line.
- Walking around with the board, **where it flashes purple and blue is where Wi-Fi is not enough**: move closer, or
  lower the sample rate.

## Check for lost samples yourself

`firmware/tools/rtl_tcp_counter.py` puts the RTL-SDR in test mode, where the chip sends an incrementing counter
instead of samples, and checks every byte on the computer, so one byte lost anywhere between USB and Wi-Fi shows.
It needs only Python 3:

```bash
firmware/tools/rtl_tcp_counter.py 192.168.7.1 --udp --rate 2.0M --seconds 60
```

A last line of `PASS: every sample, in place, at the full rate` means nothing was lost. With no RTL-SDR plugged in
the board generates the same counter itself, so the Wi-Fi half can be tested on its own. The full test sequence and
the measurements are in [firmware/bl618_rtl_udp/README.md](firmware/bl618_rtl_udp/README.md) (in Chinese).

## Layout

```
firmware/
  bl618_rtl_udp/      BL618 firmware: CherryUSB host + librtlsdr + lwIP + Wi-Fi; details in its README
  teensy41_rtl_tcp/   the wired alternative: Teensy 4.1 over Ethernet (builds, not yet run on a board)
  common/librtlsdr/   unmodified librtlsdr, shared by both firmwares
  tools/              fetching dependencies, building, flashing, the counter test
  tests/              unit tests that run on a computer
docs/images/          the diagrams on this page
hardware/carrier-v1/  the carrier board: netlist, KiCad files, parts list, bring-up record
```

Besides Wi-Fi there is a wired route in this repository: a Teensy 4.1 with Ethernet, into the iPhone through a
USB-C Ethernet adapter. It is steadier and faster, but needs soldering and an adapter to carry.
See [firmware/teensy41_rtl_tcp/README.md](firmware/teensy41_rtl_tcp/README.md). The deeper documents are in Chinese.

## Licence

The firmware contains librtlsdr (GPL-2.0-or-later), so **the BL618 firmware as a whole is GPL-2.0-or-later**;
see [LICENSE](LICENSE). Bouffalo's SDK and CherryUSB (Apache-2.0), lwIP (BSD) and FreeRTOS (MIT) are all compatible.
The Teensy firmware uses QNEthernet (AGPL-3.0-or-later) and is AGPL-3.0-or-later as a whole.

This binds only the firmware on the board. Apps on a phone or a computer talk to the board through the `rtl_tcp` and
`rtl_udp` network protocols and contain none of this code.

## KiCad design hardware/carrier-v1/carrier-v1.kicad_pcb

File hardware/carrier-v1/README.md:

# 载板 v1

Ai-M61-32S（BL618）、USB 2.0 高速 Hub、USB 转串口和一个 USB 高速 2 选 1 开关做在一块板上。RTL-SDR
仍用现成的成品，插在板载 USB-A 上。拨动开关 SW1 决定 RTL-SDR 接谁：

| SW1 | RTL-SDR 接到 | 用途 |
|---|---|---|
| Wi-Fi（MODE 低） | BL618 的 USB 主机 | 和开发板一样，经 Wi-Fi 送 rtl_tcp / rtl_udp |
| PC（MODE 高） | Hub 的下行 2 口 → USB-C | 电脑上直接看到一个 RTL2832U |

两种模式下，串口（CH343P）都挂在 Hub 的下行 1 口上，BL618 的日志和烧录始终可用。固件通过 IO31 读到当前模式，
通过 IO30 给 RTL-SDR 断电重启。指示灯和开发板一样，`led.c` 不用改：一颗 RGB 灯（红绿蓝 IO12/14/15），
会呼吸的 C 灯 IO29，W 灯 IO27。

## 文件

设计由脚本生成，改设计改 `gen/` 下的脚本，不要手改生成出来的 KiCad 文件。

| 文件 | 内容 |
|---|---|
| `gen/design.py` | 网表：每个器件、立创编号、逐脚连接 |
| `gen/gen_sch.py` | 由网表生成 `carrier-v1.kicad_sch`（网络标签式原理图） |
| `gen/check_net.py` | 把 KiCad 导出的网表和 `design.py` 逐网络比对 |
| `gen/gen_pcb.py` | 板框、四层叠层、布局、网络类别、铺铜 |
| `gen/route.py` | 自动布线（Specctra DSN → Freerouting → SES），跑两遍取好的 |
| `gen/stitch.py` | 布线后清理和补孔 |
| `gen/jlc.py` | 嘉立创下单用的 Gerber、BOM、坐标文件，输出到 `out/jlc/` |
| `lib/` | 用 easyeda2kicad 按立创编号转出的符号和封装。3D 模型（`lib/carrier.3dshapes/`，约 29 MB）不入库，渲染需要时用同一工具重新导出 |
| `parts.csv` | 物料表和选型理由 |

## 重新生成

```bash
./build.sh              # 全部，自动布线约 15 分钟
./build.sh --no-route   # 只到布局为止，用来检查摆放
```

需要 KiCad 10（`/Applications/KiCad`），以及 `hardware/tools/` 下的 Freerouting 2.1.0 和一个 Java 21 运行环境，
这两样不在仓库里（Freerouting 来自 github.com/freerouting/freerouting 的发布页，Java 用 Adoptium Temurin 21）。

## 叠层和线宽

嘉立创 4 层 JLC04161H-7628，1.6 mm。In1 整层 GND，不走线；In2 整层 +3V3，允许走线穿过；顶层和底层走线后铺 GND。

| 网络类别 | 线宽 / 间距 | 网络 |
|---|---|---|
| USB | 0.22 / 0.127 mm | 所有 `*_DP` / `*_DN`，按耦合微带估算约 94 Ω 差分（USB 2.0 要求 90 Ω ±15%） |
| Power | 0.4 / 0.2 mm | `VBUS_SDR`、`BUCK_SW` |
| Supply | 0.3 / 0.2 mm | `VBUS`、`+3V3`、`GND` |
| Default | 0.2 / 0.2 mm | 其余 |

90 Ω 是公式估算，下单前要用嘉立创的阻抗计算器按所选叠层复核。

## 状态

- 板子 62.6 × 34.6 mm，4 层。
- 原理图：ERC 0 错误；导出网表与 `design.py` 逐网络一致。
- PCB：DRC 0 未连接、0 间距违规。剩下的都不是电气问题：丝印压焊盘或板边、几个焊盘与铺铜只有一根辐条、
  USB-C 立创原封装自带的一处孔距 0.18 mm（规则 0.2 mm），以及安装孔和测试点在原理图里没有对应项。
- USB 差分对：最长的是开关到 BL618，约 24 mm、2 个过孔；其余都在 10 mm 以内、不换层；每对两根线长度差不超过 1.3 mm。
- **第一批 2 块已在实物上验证**，经过和结论见 [BRINGUP.md](BRINGUP.md)：电源、Hub、串口、两种模式、Wi-Fi 收流都正常，
  唯一的问题是模组料号，已在物料表里改正。

## 布线是怎么来的

`build.sh` 一步跑完：生成原理图 → ERC → 网表比对 → 生成 PCB → 自动布线 → 补孔 → DRC → 渲染 → 生产文件。

- **几处自动布线器每次都处理不好的地方，由 `gen_pcb.py` 按焊盘坐标直接画好并锁定**：
  - USB-C 的 D+/D− 两两相连；
  - SDR 差分对从 USB-A 经 D2 收拢进 U4；
  - D2 被差分对夹住的 GND 和 VBUS 脚；
  - U3 右侧四个引脚的扇出；
  - USB-C 的两个 VBUS 脚。
- **Freerouting 每次结果不同**，`route.py` 跑两遍，留未连接最少的一次。
- **`stitch.py` 在布线之后做四件事**：
  - 删掉悬空的线头；
  - 推开钻孔过近的过孔；
  - 按网格和孤岛补接地过孔；
  - 给 DRC 报告里仍悬空的 GND、+3V3 焊盘就近打过孔。
- **用 KiCad 自带的 Python 时不能写 `.pyc`**（`build.sh` 已设置 `PYTHONDONTWRITEBYTECODE=1`）。写进 KiCad.app 的缓存文件会破坏它的代码签名，macOS 随后会拒绝打开 KiCad，提示"已损坏"。

## 已知取舍

- **自动下载电路没做。** BL618 要 IO2 上电为高才进烧录，开发板上那套三极管电路只能拉低，安信可自己也标了 NC。
  这一版用 RESET 和 BOOT 两个按键；CH343 的 DTR 和 RTS 引到测试点 TP1、TP2，留作以后飞线。
- **模组必须用 Ai-M61-32S(ALL)，立创 C22365150。** 普通版（C22365152）的 27 脚内部不通，BOOT 键无效。
  第一批板子贴的是普通版，只能用 `flash-bl618.sh --isp` 烧录。
- **USB-A 是插件**，嘉立创贴片要选插件焊接，或者自己焊。
- **Ai-M61-32S 的天线伸出板边**，板边下方留了禁布区。
- **USB-C 一侧没有 ESD 器件。** 这一侧接电脑，而且接口的 D−/D+/D−/D+ 交错引脚和 Hub 之间放不下一颗串联的 ESD 阵列：
  它中间的引脚会被差分对围住。经常插拔的 RTL-SDR 一侧保留 D2。
- **Hub 和串口芯片都用 3.3 V 供电**（两份数据手册都给了这种接法），5 V 只到降压、RTL-SDR 限流开关和 USB-C。

Parts:
C1, C9, C15, C16, C17: 10uF; C_0805_2012Metric; LCSC C15850
C2, C3, C6, C11, C12: 1uF; C_0402_1005Metric; LCSC C52923
C4, C5, C7, C8, C10, C14: 100nF; C_0402_1005Metric; LCSC C1525
C13: 22uF; C_0805_2012Metric; LCSC C45783
D2: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C2687116
J1: USB-C; USB-C-SMD_TYPE-C-16PIN-2MD-073; LCSC C2765186
J2: USB-A; USB-A-TH_C46407; LCSC C46407
L1: 2.2uH; IND-SMD_L5.0-W5.0; LCSC C9941
LED1: RGB; LED-SMD-6P_S6-3528RGBTA; LCSC C2843672
LED4: white PC; LED_0603_1608Metric; LCSC C2290
LED5: white C; LED_0603_1608Metric; LCSC C2290
LED6: yellow W; LED_0603_1608Metric; LCSC C2287
R1, R2: 5.1k; R_0402_1005Metric; LCSC C25905
R3, R11: 100k; R_0402_1005Metric; LCSC C25741
R4, R8, R13, R14, R15, R16: 470; R_0402_1005Metric; LCSC C25117
R5, R6, R9, R10: 10k; R_0402_1005Metric; LCSC C25744
R7: 1k; R_0402_1005Metric; LCSC C11702
R12: 22k; R_0402_1005Metric; LCSC C25768
SW1: Wi-Fi / PC; SW-TH_MSK12C02; LCSC C431540
SW2: RESET; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; LCSC C318884
SW3: BOOT; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; LCSC C318884
TP1: DTR; TestPoint_Pad_D1.0mm
TP2: RTS; TestPoint_Pad_D1.0mm
U1: Ai-M61-32S(ALL); WIRELM-SMD_AI-M61-32S; LCSC C22365150
U2: CH334P; QFN-16_L3.0-W3.0-P0.50-BL-EP1.7; LCSC C5373042
U3: CH343P; TQFN-16_L3.0-W3.0-P0.50-BL-EP1.7; LCSC C2846043
U4: TS3USB221RSER; UQFN-10_L2.0-W1.5-P0.50-BL; LCSC C130085
U5: SY6280AAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; LCSC C55136
U6: TLV62569DBVR; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC C141836
Y1: 12MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL; LCSC C9002

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C16.1, C17.1, L1.2, R5.1, R10.1, R11.1, SW1.3, SW3.1 (A), SW3.2 (B), U1.2 (VCC), U2.15 (V5), U2.16 (VDD33), U3.1 (VIO), U3.3 (VDD5), U3.6 (V3), U3.9 (VBUS), U4.10 (VCC)
BL_DN: U1.25 (USB-DM), U4.2 (1D-)
BL_DP: U1.24 (USB-DP), U4.1 (1D+)
BL_RX: U1.36 (RXD), U3.4 (TXD)
BL_TX: U1.37 (TXD), U3.5 (RXD)
BOOT: R6.1, R7.2, U1.27 (IO2/NC)
BOOT_KEY: R7.1, SW3.3 (C), SW3.4 (D)
BUCK_FB: R11.2, R12.1, U6.5 (FB)
BUCK_SW: L1.1, U6.3 (SW)
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
DTR: TP1.1, U3.12 (DTRTNOW)
EN: C11.1, R5.2, SW2.1 (A), SW2.2 (B), U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D2.2 (GND), J1.13 (EH), J1.14 (EH), J1.A1B12 (GND), J1.B1A12 (GND), J2.4 (GND), J2.5, J2.6, LED4.1 (K), LED5.1 (K), LED6.1 (K), R1.2, R2.2, R3.2, R6.2, R8.2, R9.2, R12.2, R13.2, R14.2, SW1.1, SW1.4, SW2.3 (C), SW2.4 (D), U1.1 (GND), U1.41 (EP), U2.17 (GND), U3.2 (GND), U3.17 (EP), U4.5 (GND), U4.6 (~OE), U5.2 (GND), U6.2 (GND), Y1.2 (GND), Y1.4 (GND)
HUB1_DN: U2.9 (DM1), U3.8 (UD-)
HUB1_DP: U2.10 (DP1), U3.7 (UD+)
HUB2_DN: U2.7 (DM2), U4.4 (2D-)
HUB2_DP: U2.8 (DP2), U4.3 (2D+)
HUB_XI: U2.2 (XI), Y1.1 (OSC1)
HUB_XO: U2.1 (XO), Y1.3 (OSC2)
LED_B: LED1.6, U1.10 (IO15)
LED_B_K: LED1.1, R14.1
LED_C: R15.1, U1.33 (IO29)
LED_C_A: LED5.2 (A), R15.2
LED_G: LED1.4, U1.9 (IO14)
LED_G_K: LED1.3, R13.1
LED_PC: LED4.2 (A), R4.2
LED_R: LED1.5, U1.8 (IO12)
LED_R_K: LED1.2, R8.1
LED_W: R16.1, U1.32 (IO27)
LED_W_A: LED6.2 (A), R16.2
MODE: R3.1, R4.1, SW1.2, U1.35 (IO31), U4.9 (S)
RTS: TP2.1, U3.13 (RTS)
SDR_DN: D2.3 (I/O2), D2.4 (I/O2), J2.2 (D-), U4.7 (D-)
SDR_DP: D2.1 (I/O1), D2.6 (I/O1), J2.3 (D+), U4.8 (D+)
SDR_ISET: R9.1, U5.3 (ISET)
SDR_PWR_EN: R10.2, U1.34 (IO30), U5.4 (EN)
USBC_DN: J1.A7 (Dn1), J1.B7 (Dn2), U2.11 (DMU)
USBC_DP: J1.A6 (Dp1), J1.B6 (Dp2), U2.12 (DPU)
VBUS: C1.1, C12.1, C15.1, J1.A4B9 (VBUS), J1.B4A9 (VBUS), U5.5 (IN), U6.1 (EN), U6.4 (VIN)
VBUS_SDR: C13.1, C14.1, D2.5 (VBUS), J2.1 (VCC), U5.1 (OUT)

Notes on the sheet:
USB-C 输入（电脑 / 充电头）
5V → 3.3V 降压
USB Hub：上行接 USB-C，下行 1 口接串口，2 口接开关
USB 转串口：BL618 日志和烧录
USB 开关：S=低 RTL-SDR 接 BL618，S=高 接 Hub（电脑）
RTL-SDR 接口：限流供电 + USB-A
Ai-M61-32S（BL618）

Board: 4 copper layers, 62.6 x 34.6 mm, 56 parts (0 on the bottom side), 41 nets.

Other parts of the board:
H1, H2, H3: MountingHole_2.2mm_M2
